# Keil uVision project bk3633.uvproj, settings and files
target BK3633_bim (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: bk3633_boot +hex
  AfterMake: fromelf --bin --output .\output\bk3633_boot.bin .\obj\bk3633_boot.axf
  AfterMake: .\output\encrypt_bim.bat
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: .\app;..\..\arch
  asm include: .\src\plf\refip\src\arch\ll
  library: MicroLIB
  scatter file: .\lnk\link_bim.txt
  link misc: --entry sys_Reset --symdefs=.\lnk\bim_rom_symbol.txt --noremove
  group bim
    ./app/: bim_app.c bim_intc.c bim_vectors.s bim_handlers.s bim_flash.c bim_uart2 .c bim_icu.c bim_wdt.c bim_gpio.c bim_updataImage.c
target BK3633_stack (ARM-ADS)
  device: ARM9E-S (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM9E)
  output: bk3435_ble_bim
  AfterMake: fromelf --bin --output .\output\bk3435_ble_bim.bin .\obj\bk3435_ble_bim.axf
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c misc: --c99
  c include: ..\..\sdk\plactform\src\core_modules\ke\api;..\..\sdk\plactform\src\core_modules\nvds\api;..\..\sdk\plactform\src\core_modules\h4tl\api;..\..\sdk\plactform\src\core_modules\rwip\api;..\..\sdk\plactform\src\core_modules\src;..\..\sdk\plactform\src\arch;..\..\sdk\plactform\src\arch\compiler;..\..\sdk\plactform\src\arch\ll;..\..\sdk\plactform\src\core_modules\common\api;..\..\sdk\plactform\src\driver\timer;..\..\sdk\plactform\src\build\ble-full\reg\fw;..\..\sdk\plactform\src\driver\reg;..\..\sdk\plactform\src\driver\emi;..\..\sdk\plactform\src\arch\boot;..\..\sdk\plactform\src\driver\intc;..\..\sdk\ble_stack\hci\api;..\..\sdk\plactform\src\driver\syscntl;..\..\sdk\plactform\src\driver\flash;..\..\sdk\ble_stack\ahi\api;..\..\sdk\ble_stack\ble\ll\src\em;..\..\sdk\ble_stack\ea\api;..\..\sdk\plactform\src\core_modules\dbg\api;..\..\sdk\ble_stack\ble\ll\src\rwble;..\..\sdk\ble_stack\ble\ll\src\llc;..\..\sdk\ble_stack\em\api;..\..\sdk\ble_stack\ble\ll\src\lld;..\..\sdk\ble_stack\ble\ll\src\llm;..\..\sdk\plactform\src\core_modules\rf\api;..\..\sdk\ble_stack\ble\hl\src\gatt\attc;..\..\sdk\ble_stack\ble\profiles;..\..\sdk\ble_stack\ble\profiles\FFF0\api;..\..\sdk\plactform\src\core_modules\rf\api;..\..\sdk\plactform\src\driver\plf;..\..\sdk\plactform\src\driver\counter;..\..\sdk\plactform\src\driver\intcntl;..\..\sdk\plactform\src\driver\icu;..\..\sdk\plactform\src\rom\hci;..\..\sdk\ble_stack\ble\hl\inc;..\..\sdk\ble_stack\ble\hl\api;..\..\sdk\ble_stack\ble\hl\src\gap;..\..\sdk\ble_stack\ble\hl\src\gap\gapm;..\..\sdk\ble_stack\ble\hl\src\gap\gapc;..\..\sdk\ble_stack\ble\hl\src\gap\smpm;..\..\sdk\ble_stack\ble\hl\src\gap\smpc;..\..\sdk\ble_stack\ble\hl\src\gatt;..\..\sdk\ble_stack\ble\hl\src\gatt\attm;..\..\sdk\ble_stack\ble\hl\src\gatt\attc;..\..\sdk\ble_stack\ble\hl\src\gatt\atts;..\..\sdk\ble_stack\ble\hl\src\gatt\gattm;..\..\sdk\ble_stack\ble\hl\src\gatt\gattc;..\..\sdk\ble_stack\ble\hl\src\l2c\l2cm;..\..\sdk\ble_stack\ble\hl\src\l2c\l2cc;..\..\sdk\plactform\src\core_modules\ecc_p256\api;..\..\sdk\plactform\src\core_modules\ke\src;..\..\sdk\plactform\src\core_modules\nvds\api;..\..\sdk\plactform\src\core_modules\enc;.\config;.\app
  asm include: .\src\plf\refip\src\arch\ll
  library: MicroLIB
  scatter file: .\lnk\link_bim.txt
  link misc: --entry sys_Reset --symdefs=.\lnk\rom_symbol_peripheral.txt --noremove
